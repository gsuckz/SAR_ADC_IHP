v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
T {CDAC full Diferencial 12 Bits } 230 -2380 0 0 1.2 1.2 {}
T {Agregar NOL en Vin/Vcm
Agregar Capacitor Split
Cambiar la última Celda por algo sin BIT} 1970 -2560 0 0 1.2 1.2 {}
N 3900 -2140 3900 -1920 {lab=a_rail_p}
N 3560 -2140 3560 -1920 {lab=a_rail_p}
N 3210 -2140 3210 -1930 {lab=a_rail_p}
N 500 -2140 500 -1970 {lab=a_rail_p}
N 150 -2140 150 -1980 {lab=a_rail_p}
N 150 -2140 500 -2140 {lab=a_rail_p}
N 840 -2140 840 -1970 {lab=a_rail_p}
N 500 -2140 840 -2140 {lab=a_rail_p}
N 1200 -2140 1200 -1960 {lab=a_rail_p}
N 840 -2140 1200 -2140 {lab=a_rail_p}
N 1550 -2140 1550 -1950 {lab=a_rail_p}
N 1890 -2140 1890 -1950 {lab=a_rail_p}
N 1200 -2140 1550 -2140 {lab=a_rail_p}
N 2160 -2140 2160 -1950 {lab=a_rail_p}
N 1890 -2140 2160 -2140 {lab=a_rail_p}
N 1550 -2140 1890 -2140 {lab=a_rail_p}
N 2510 -2140 2510 -1940 {lab=a_rail_p}
N 2160 -2140 2510 -2140 {lab=a_rail_p}
N 3560 -2140 3900 -2140 {lab=a_rail_p}
N 3210 -2140 3560 -2140 {lab=a_rail_p}
N 2850 -2140 3210 -2140 {lab=a_rail_p}
N 2850 -2140 2850 -1940 {lab=a_rail_p}
N 2510 -2140 2850 -2140 {lab=a_rail_p}
N 540 -1810 540 -1640 {lab=vdacn}
N 190 -1800 190 -1640 {lab=vdacn}
N 190 -1640 540 -1640 {lab=vdacn}
N 880 -1810 880 -1640 {lab=vdacn}
N 540 -1640 880 -1640 {lab=vdacn}
N 1240 -1820 1240 -1640 {lab=vdacn}
N 880 -1640 1240 -1640 {lab=vdacn}
N 2200 -1640 2550 -1640 {lab=vdacn2}
N 2550 -1640 2890 -1640 {lab=vdacn2}
N 4185 -1640 4220 -1640 {lab=vdacn2}
N 3600 -1640 3940 -1640 {lab=vdacn2}
N 3250 -1640 3600 -1640 {lab=vdacn2}
N 2890 -1640 3250 -1640 {lab=vdacn2}
N 1590 -1770 1590 -1640 {lab=vdacn}
N 1240 -1640 1590 -1640 {lab=vdacn}
N 1930 -1770 1930 -1640 {lab=vdacn}
N 1590 -1640 1930 -1640 {lab=vdacn}
N 3940 -1740 3940 -1640 {lab=vdacn2}
N 3600 -1740 3600 -1640 {lab=vdacn2}
N 3250 -1750 3250 -1640 {lab=vdacn2}
N 2890 -1760 2890 -1640 {lab=vdacn2}
N 2550 -1760 2550 -1640 {lab=vdacn2}
N 2200 -1770 2200 -1640 {lab=vdacn2}
N 0 -2140 150 -2140 {lab=a_rail_p}
N -40 -1640 190 -1640 {lab=vdacn}
N -50 -2140 0 -2140 {lab=a_rail_p}
N -210 -1640 -200 -1640 {lab=vcm}
N -565 -1980 -540 -1980 {lab=sample}
N -700 -1940 -700 -1920 {lab=VSS}
N -700 -2040 -700 -2020 {lab=VDD}
N -50 -1870 0 -1870 {lab=a_rail_p}
N 0 -2140 0 -1870 {lab=a_rail_p}
N -210 -1870 -210 -1640 {lab=vcm}
N -420 -1640 -210 -1640 {lab=vcm}
N 3930 -1380 3930 -1160 {lab=a_rail_n}
N 3590 -1380 3590 -1160 {lab=a_rail_n}
N 3240 -1380 3240 -1170 {lab=a_rail_n}
N 530 -1380 530 -1210 {lab=a_rail_n}
N 180 -1380 180 -1220 {lab=a_rail_n}
N 180 -1380 530 -1380 {lab=a_rail_n}
N 870 -1380 870 -1210 {lab=a_rail_n}
N 530 -1380 870 -1380 {lab=a_rail_n}
N 1230 -1380 1230 -1200 {lab=a_rail_n}
N 870 -1380 1230 -1380 {lab=a_rail_n}
N 1580 -1380 1580 -1190 {lab=a_rail_n}
N 1920 -1380 1920 -1190 {lab=a_rail_n}
N 1230 -1380 1580 -1380 {lab=a_rail_n}
N 2190 -1375 2190 -1190 {lab=a_rail_n}
N 1920 -1380 2190 -1380 {lab=a_rail_n}
N 1580 -1380 1920 -1380 {lab=a_rail_n}
N 2540 -1375 2540 -1180 {lab=a_rail_n}
N 2190 -1375 2540 -1375 {lab=a_rail_n}
N 3590 -1380 3930 -1380 {lab=a_rail_n}
N 3240 -1380 3590 -1380 {lab=a_rail_n}
N 2880 -1380 3240 -1380 {lab=a_rail_n}
N 2880 -1380 2880 -1180 {lab=a_rail_n}
N 2540 -1380 2880 -1380 {lab=a_rail_n}
N 570 -1050 570 -880 {lab=vdacp}
N 220 -1040 220 -880 {lab=vdacp}
N 235 -880 570 -880 {lab=vdacp}
N 910 -1050 910 -880 {lab=vdacp}
N 570 -880 910 -880 {lab=vdacp}
N 1270 -1060 1270 -880 {lab=vdacp}
N 910 -880 1270 -880 {lab=vdacp}
N 2230 -880 2580 -880 {lab=vdacp2}
N 2835 -880 2920 -880 {lab=vdacp2}
N 3970 -880 4230 -880 {lab=vdacp2}
N 3630 -880 3970 -880 {lab=vdacp2}
N 3280 -880 3630 -880 {lab=vdacp2}
N 2920 -880 3280 -880 {lab=vdacp2}
N 1620 -1010 1620 -880 {lab=vdacp}
N 1270 -880 1620 -880 {lab=vdacp}
N 1960 -1010 1960 -880 {lab=vdacp}
N 4230 -980 4230 -880 {lab=vdacp2}
N 3970 -980 3970 -880 {lab=vdacp2}
N 3630 -980 3630 -880 {lab=vdacp2}
N 3280 -990 3280 -880 {lab=vdacp2}
N 2920 -1000 2920 -880 {lab=vdacp2}
N 2580 -1000 2580 -880 {lab=vdacp2}
N 2230 -1010 2230 -880 {lab=vdacp2}
N 2150 -880 2230 -880 {lab=vdacp2}
N 30 -1380 180 -1380 {lab=a_rail_n}
N -10 -880 220 -880 {lab=vdacp}
N -20 -1380 30 -1380 {lab=a_rail_n}
N -180 -880 -170 -880 {lab=vcm}
N -20 -1110 30 -1110 {lab=a_rail_n}
N 30 -1380 30 -1110 {lab=a_rail_n}
N -180 -1110 -180 -880 {lab=vcm}
N -420 -1640 -420 -1110 {lab=vcm}
N -420 -1110 -180 -1110 {lab=vcm}
N -995 -1940 -995 -1920 {lab=VSS}
N -995 -2040 -995 -2020 {lab=VDD}
N -915 -1980 -760 -1980 {lab=sample_n}
N 1930 -1640 2045 -1640 {lab=vdacn}
N 1960 -880 2090 -880 {lab=vdacp}
N 1620 -880 1960 -880 {lab=vdacp}
N 2100 -1640 2200 -1640 {lab=vdacn2}
N 4440 -1695 4450 -1695 {lab=vcm}
N 2595 -700 2605 -700 {lab=vcm}
N 2765 -700 2835 -700 {lab=vdacp2}
N 2835 -880 2835 -700 {lab=vdacp2}
N 2580 -880 2835 -880 {lab=vdacp2}
N 4610 -1700 4610 -1515 {lab=vdacn2}
N 4175 -1515 4610 -1515 {lab=vdacn2}
N 4175 -1640 4175 -1515 {lab=vdacn2}
N 3940 -1640 4175 -1640 {lab=vdacn2}
N 4185 -1805 4185 -1640 {lab=vdacn2}
N 4175 -1640 4185 -1640 {lab=vdacn2}
N 3900 -2140 4195 -2140 {lab=a_rail_p}
N 4195 -2140 4195 -1865 {lab=a_rail_p}
N 4185 -1865 4195 -1865 {lab=a_rail_p}
N 4230 -1380 4235 -1380 {lab=a_rail_n}
N 4230 -1380 4230 -1040 {lab=a_rail_n}
N 3930 -1380 4230 -1380 {lab=a_rail_n}
N 235 -880 235 -865 {lab=vdacp}
N 220 -880 235 -880 {lab=vdacp}
N 540 -1640 540 -1625 {lab=vdacn}
N -650 -1730 -570 -1730 {lab=sample_d}
N -730 -1690 -730 -1670 {lab=VSS}
N -730 -1790 -730 -1770 {lab=VDD}
N -1025 -1690 -1025 -1670 {lab=VSS}
N -1025 -1790 -1025 -1770 {lab=VDD}
N -945 -1730 -790 -1730 {lab=sample_n_d}
N -1165 -1900 -565 -1900 {lab=sample}
N -1135 -1980 -1055 -1980 {lab=sample_pin}
N -565 -1980 -565 -1900 {lab=sample}
N -620 -1980 -565 -1980 {lab=sample}
N 2190 -1380 2190 -1375 {lab=a_rail_n}
N 2540 -1380 2540 -1375 {lab=a_rail_n}
C {dac_icms_cell/unit_cell_n.sym} 190 -1820 0 0 {name=x14 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=32}
C {devices/ipin.sym} 110 -1900 0 0 {name=p15 lab=D0}
C {devices/ipin.sym} 210 -1980 1 0 {name=p16 lab=b0}
C {lab_pin.sym} 230 -1800 3 0 {name=p19 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 230 -1980 1 0 {name=p40 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 540 -1810 0 0 {name=x15 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=16}
C {devices/ipin.sym} 460 -1890 0 0 {name=p41 lab=D1}
C {devices/ipin.sym} 560 -1970 1 0 {name=p49 lab=b1}
C {lab_pin.sym} 580 -1790 3 0 {name=p71 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 580 -1970 1 0 {name=p74 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 880 -1810 0 0 {name=x16 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=8}
C {devices/ipin.sym} 800 -1890 0 0 {name=p76 lab=D2}
C {devices/ipin.sym} 900 -1970 1 0 {name=p79 lab=b2}
C {lab_pin.sym} 920 -1790 3 0 {name=p81 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 920 -1970 1 0 {name=p82 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 1240 -1800 0 0 {name=x1 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=4}
C {devices/ipin.sym} 1160 -1880 0 0 {name=p1 lab=D3}
C {devices/ipin.sym} 1260 -1960 1 0 {name=p2 lab=b3}
C {lab_pin.sym} 1280 -1780 3 0 {name=p3 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1280 -1960 1 0 {name=p4 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 1590 -1790 0 0 {name=x2 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=2}
C {devices/ipin.sym} 1510 -1870 0 0 {name=p5 lab=D4}
C {devices/ipin.sym} 1610 -1950 1 0 {name=p6 lab=b4}
C {lab_pin.sym} 1630 -1770 3 0 {name=p7 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1630 -1950 1 0 {name=p8 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 1930 -1790 0 0 {name=x3 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=1}
C {devices/ipin.sym} 1850 -1870 0 0 {name=p9 lab=D5}
C {devices/ipin.sym} 1950 -1950 1 0 {name=p10 lab=b5}
C {lab_pin.sym} 1970 -1770 3 0 {name=p11 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1970 -1950 1 0 {name=p12 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 2200 -1790 0 0 {name=x4 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=32}
C {devices/ipin.sym} 2120 -1870 0 0 {name=p13 lab=D6}
C {devices/ipin.sym} 2220 -1950 1 0 {name=p14 lab=b6}
C {lab_pin.sym} 2240 -1770 3 0 {name=p17 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2240 -1950 1 0 {name=p18 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 2550 -1780 0 0 {name=x5 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=16}
C {devices/ipin.sym} 2470 -1860 0 0 {name=p20 lab=D7}
C {devices/ipin.sym} 2570 -1940 1 0 {name=p21 lab=b7}
C {lab_pin.sym} 2590 -1760 3 0 {name=p22 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2590 -1940 1 0 {name=p23 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 2890 -1780 0 0 {name=x6 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=8}
C {devices/ipin.sym} 2810 -1860 0 0 {name=p24 lab=D8}
C {devices/ipin.sym} 2910 -1940 1 0 {name=p25 lab=b8}
C {lab_pin.sym} 2930 -1760 3 0 {name=p26 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2930 -1940 1 0 {name=p27 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 3250 -1770 0 0 {name=x7 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=4}
C {devices/ipin.sym} 3170 -1850 0 0 {name=p28 lab=D9}
C {devices/ipin.sym} 3270 -1930 1 0 {name=p29 lab=b9}
C {lab_pin.sym} 3290 -1750 3 0 {name=p30 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3290 -1930 1 0 {name=p31 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 3600 -1760 0 0 {name=x8 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=2}
C {devices/ipin.sym} 3520 -1840 0 0 {name=p32 lab=D10}
C {devices/ipin.sym} 3620 -1920 1 0 {name=p33 lab=b10}
C {lab_pin.sym} 3640 -1740 3 0 {name=p34 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3640 -1920 1 0 {name=p35 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell_n.sym} 3940 -1760 0 0 {name=x9 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=1}
C {devices/ipin.sym} 3860 -1840 0 0 {name=p36 lab=D11}
C {devices/ipin.sym} 3960 -1920 1 0 {name=p37 lab=b11}
C {lab_pin.sym} 3980 -1740 3 0 {name=p38 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3980 -1920 1 0 {name=p39 sig_type=std_logic lab=VDD}
C {transmission_gate/transmission_gate_lv_w_dummy.sym} -120 -1640 0 0 {name=x11 W_P=0.15u L_P=0.13u W_N=0.15u L_N=0.13u
n=64}
C {lab_pin.sym} -140 -1680 1 0 {name=p46 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -140 -1600 3 0 {name=p47 sig_type=std_logic lab=VSS}
C {transmission_gate/transmission_gate_lv_w_dummy.sym} -130 -2140 0 0 {name=x12 W_P=0.15u L_P=0.13u W_N=0.15u L_N=0.13u
n=64}
C {devices/iopin.sym} -210 -2140 0 0 {name=p48 lab=vinp}
C {transmission_gate/transmission_gate_lv_w_dummy.sym} -130 -1870 0 0 {name=x13 W_P=0.15u L_P=0.13u W_N=0.15u L_N=0.13u
n=64}
C {lab_pin.sym} -150 -1910 1 0 {name=p50 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -150 -1830 3 0 {name=p51 sig_type=std_logic lab=VSS}
C {devices/iopin.sym} -420 -1360 0 0 {name=p52 lab=vcm}
C {lab_pin.sym} -540 -1980 0 1 {name=p54 sig_type=std_logic lab=sample}
C {inverter/inverter_lv.sym} -700 -1980 0 0 {name=x17 W_P=10.0u L_P=0.13u W_N=10.0u L_N=0.13u n=10
}
C {lab_pin.sym} -700 -1920 3 0 {name=p55 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -700 -2040 1 0 {name=p56 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -120 -1600 1 1 {name=p57 sig_type=std_logic lab=sample_n}
C {lab_pin.sym} -120 -1680 3 1 {name=p58 sig_type=std_logic lab=sample}
C {devices/ipin.sym} -1135 -1980 0 0 {name=p59 lab=sample_pin}
C {lab_pin.sym} -130 -2100 1 1 {name=p53 sig_type=std_logic lab=sample_n}
C {lab_pin.sym} -130 -2180 3 1 {name=p60 sig_type=std_logic lab=sample}
C {lab_pin.sym} -130 -1910 1 0 {name=p61 sig_type=std_logic lab=sample_n_d}
C {lab_pin.sym} -130 -1830 3 0 {name=p62 sig_type=std_logic lab=sample_d}
C {lab_pin.sym} -150 -2180 1 0 {name=p63 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -150 -2100 3 0 {name=p64 sig_type=std_logic lab=VSS}
C {dac_icms_cell/unit_cell.sym} 220 -1060 0 0 {name=x18 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=32}
C {devices/lab_pin.sym} 140 -1140 0 0 {name=p65 lab=D0}
C {devices/lab_pin.sym} 240 -1220 1 0 {name=p66 lab=b0}
C {lab_pin.sym} 260 -1040 3 0 {name=p67 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 260 -1220 1 0 {name=p68 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 570 -1050 0 0 {name=x19 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=16}
C {devices/lab_pin.sym} 490 -1130 0 0 {name=p69 lab=D1}
C {devices/lab_pin.sym} 590 -1210 1 0 {name=p70 lab=b1}
C {lab_pin.sym} 610 -1030 3 0 {name=p72 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 610 -1210 1 0 {name=p73 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 910 -1050 0 0 {name=x20 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=8}
C {devices/lab_pin.sym} 830 -1130 0 0 {name=p75 lab=D2}
C {devices/lab_pin.sym} 930 -1210 1 0 {name=p77 lab=b2}
C {lab_pin.sym} 950 -1030 3 0 {name=p78 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 950 -1210 1 0 {name=p80 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 1270 -1040 0 0 {name=x21 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=4}
C {devices/lab_pin.sym} 1190 -1120 0 0 {name=p83 lab=D3}
C {devices/lab_pin.sym} 1290 -1200 1 0 {name=p84 lab=b3}
C {lab_pin.sym} 1310 -1020 3 0 {name=p85 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1310 -1200 1 0 {name=p86 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 1620 -1030 0 0 {name=x22 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=2}
C {devices/lab_pin.sym} 1540 -1110 0 0 {name=p87 lab=D4}
C {devices/lab_pin.sym} 1640 -1190 1 0 {name=p88 lab=b4}
C {lab_pin.sym} 1660 -1010 3 0 {name=p89 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1660 -1190 1 0 {name=p90 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 1960 -1030 0 0 {name=x23 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=1}
C {devices/lab_pin.sym} 1880 -1110 0 0 {name=p91 lab=D5}
C {devices/lab_pin.sym} 1980 -1190 1 0 {name=p92 lab=b5}
C {lab_pin.sym} 2000 -1010 3 0 {name=p93 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2000 -1190 1 0 {name=p94 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 2230 -1030 0 0 {name=x24 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=32}
C {devices/lab_pin.sym} 2150 -1110 0 0 {name=p95 lab=D6}
C {devices/lab_pin.sym} 2250 -1190 1 0 {name=p96 lab=b6}
C {lab_pin.sym} 2270 -1010 3 0 {name=p97 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2270 -1190 1 0 {name=p98 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 2580 -1020 0 0 {name=x25 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=16}
C {devices/lab_pin.sym} 2500 -1100 0 0 {name=p99 lab=D7}
C {devices/lab_pin.sym} 2600 -1180 1 0 {name=p100 lab=b7}
C {lab_pin.sym} 2620 -1000 3 0 {name=p101 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2620 -1180 1 0 {name=p102 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 2920 -1020 0 0 {name=x26 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=8}
C {devices/lab_pin.sym} 2840 -1100 0 0 {name=p103 lab=D8}
C {devices/lab_pin.sym} 2940 -1180 1 0 {name=p104 lab=b8}
C {lab_pin.sym} 2960 -1000 3 0 {name=p105 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2960 -1180 1 0 {name=p106 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 3280 -1010 0 0 {name=x27 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=4}
C {devices/lab_pin.sym} 3200 -1090 0 0 {name=p107 lab=D9}
C {devices/lab_pin.sym} 3300 -1170 1 0 {name=p108 lab=b9}
C {lab_pin.sym} 3320 -990 3 0 {name=p109 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3320 -1170 1 0 {name=p110 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 3630 -1000 0 0 {name=x28 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=2}
C {devices/lab_pin.sym} 3550 -1080 0 0 {name=p111 lab=D10}
C {devices/lab_pin.sym} 3650 -1160 1 0 {name=p112 lab=b10}
C {lab_pin.sym} 3670 -980 3 0 {name=p113 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 3670 -1160 1 0 {name=p114 sig_type=std_logic lab=VDD}
C {dac_icms_cell/unit_cell.sym} 3970 -1000 0 0 {name=x29 W_P_SPDT=1.0u L_P_SPDT=0.13u W_N_SPDT=1.0u L_N_SPDT=0.13u Cu=cu
n=1}
C {devices/lab_pin.sym} 3890 -1080 0 0 {name=p115 lab=D11}
C {devices/lab_pin.sym} 3990 -1160 1 0 {name=p116 lab=b11}
C {lab_pin.sym} 4010 -980 3 0 {name=p117 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4010 -1160 1 0 {name=p118 sig_type=std_logic lab=VDD}
C {transmission_gate/transmission_gate_lv_w_dummy.sym} -90 -880 0 0 {name=x31 W_P=0.15u L_P=0.13u W_N=0.15u L_N=0.13u
n=64}
C {lab_pin.sym} -110 -920 1 0 {name=p122 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -110 -840 3 0 {name=p123 sig_type=std_logic lab=VSS}
C {transmission_gate/transmission_gate_lv_w_dummy.sym} -100 -1380 0 0 {name=x32 W_P=0.15u L_P=0.13u W_N=0.15u L_N=0.13u
n=64}
C {devices/iopin.sym} -180 -1380 0 0 {name=p124 lab=vinn}
C {transmission_gate/transmission_gate_lv_w_dummy.sym} -100 -1110 0 0 {name=x33 W_P=0.15u L_P=0.13u W_N=0.15u L_N=0.13u
n=64}
C {lab_pin.sym} -120 -1150 1 0 {name=p125 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -120 -1070 3 0 {name=p126 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -90 -840 1 1 {name=p128 sig_type=std_logic lab=sample_n}
C {lab_pin.sym} -90 -920 3 1 {name=p129 sig_type=std_logic lab=sample}
C {lab_pin.sym} -100 -1340 1 1 {name=p130 sig_type=std_logic lab=sample_n}
C {lab_pin.sym} -100 -1420 3 1 {name=p131 sig_type=std_logic lab=sample}
C {lab_pin.sym} -100 -1150 1 0 {name=p132 sig_type=std_logic lab=sample_n_d}
C {lab_pin.sym} -100 -1070 3 0 {name=p133 sig_type=std_logic lab=sample_d}
C {lab_pin.sym} -120 -1420 1 0 {name=p134 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -120 -1340 3 0 {name=p135 sig_type=std_logic lab=VSS}
C {devices/iopin.sym} 235 -869 1 0 {name=p137 lab=vdacp}
C {devices/iopin.sym} 540 -1629 1 0 {name=p138 lab=vdacn}
C {iopin.sym} -1400 -1805 3 0 {name=p127 sig_type=std_logic lab=VSS}
C {iopin.sym} -1400 -1785 1 0 {name=p139 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -845 -1980 1 0 {name=p140 sig_type=std_logic lab=sample_n}
C {inverter/inverter_lv.sym} -995 -1980 0 0 {name=x34 W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u n=10
}
C {lab_pin.sym} -995 -1920 3 0 {name=p141 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -995 -2040 1 0 {name=p142 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 210 -2140 3 1 {name=p143 sig_type=std_logic lab=a_rail_p}
C {lab_pin.sym} 250 -1380 3 1 {name=p144 sig_type=std_logic lab=a_rail_n}
C {capa.sym} 2075 -1640 1 1 {name=C1
m=1
value=cu
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 2120 -880 1 0 {name=C2
m=1
value=cu
footprint=1206
device="ceramic capacitor"}
C {transmission_gate/transmission_gate_lv_w_dummy.sym} 4530 -1695 0 0 {name=x35 W_P=0.15u L_P=0.13u W_N=0.15u L_N=0.13u
n=64}
C {lab_pin.sym} 4510 -1735 1 0 {name=p145 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 4510 -1655 3 0 {name=p146 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 4530 -1655 1 1 {name=p147 sig_type=std_logic lab=sample_n}
C {lab_pin.sym} 4530 -1735 3 1 {name=p148 sig_type=std_logic lab=sample}
C {transmission_gate/transmission_gate_lv_w_dummy.sym} 2685 -700 0 0 {name=x36 W_P=0.15u L_P=0.13u W_N=0.15u L_N=0.13u
n=64}
C {lab_pin.sym} 2665 -740 1 0 {name=p149 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2665 -660 3 0 {name=p150 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2685 -660 1 1 {name=p151 sig_type=std_logic lab=sample_n}
C {lab_pin.sym} 2685 -740 3 1 {name=p152 sig_type=std_logic lab=sample}
C {lab_pin.sym} 2605 -700 3 1 {name=p153 sig_type=std_logic lab=vcm}
C {lab_pin.sym} 4440 -1695 3 1 {name=p154 sig_type=std_logic lab=vcm}
C {capa.sym} 4185 -1835 2 1 {name=C3
m=1
value=cu
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 4230 -1010 2 1 {name=C4
m=1
value=cu
footprint=1206
device="ceramic capacitor"}
C {lab_pin.sym} 3055 -880 3 0 {name=p42 sig_type=std_logic lab=vdacp2}
C {lab_pin.sym} 3075 -1640 3 0 {name=p43 sig_type=std_logic lab=vdacn2}
C {lab_pin.sym} -570 -1730 0 1 {name=p44 sig_type=std_logic lab=sample_d}
C {inverter/inverter_lv.sym} -730 -1730 0 0 {name=x10 W_P=10.0u L_P=0.13u W_N=10.0u L_N=0.13u n=10
}
C {lab_pin.sym} -730 -1670 3 0 {name=p45 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -730 -1790 1 0 {name=p119 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -875 -1730 1 0 {name=p120 sig_type=std_logic lab=sample_n_d}
C {inverter/inverter_lv.sym} -1025 -1730 0 0 {name=x30 W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u n=10
}
C {lab_pin.sym} -1025 -1670 3 0 {name=p121 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -1025 -1790 1 0 {name=p136 sig_type=std_logic lab=VDD}
C {sg13g2_stdcells/sg13g2_dlygate4sd3_1.sym} -1125 -1730 0 0 {name=x37 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} -1165 -1730 1 0 {name=p155 sig_type=std_logic lab=VDD}
