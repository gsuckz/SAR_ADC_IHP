** sch_path: xschem/dac_icms_cell/dac.sch
**.subckt dac D0 b0 vinn vcm sample_pin vinp vdacp vdacn VSS VDD D1 b1 D2 b2 D3 b3 D4 b4 D5 b5 b6 D7
*+ b7 D8 b8 D9 b9 D10 b10 D11 b11 D6 inv_vcm
*.ipin D0
*.ipin b0
*.iopin vinn
*.iopin vcm
*.ipin sample_pin
*.iopin vinp
*.iopin vdacp
*.iopin vdacn
*.iopin VSS
*.iopin VDD
*.ipin D1
*.ipin b1
*.ipin D2
*.ipin b2
*.ipin D3
*.ipin b3
*.ipin D4
*.ipin b4
*.ipin D5
*.ipin b5
*.ipin b6
*.ipin D7
*.ipin b7
*.ipin D8
*.ipin b8
*.ipin D9
*.ipin b9
*.ipin D10
*.ipin b10
*.ipin D11
*.ipin b11
*.ipin D6
*.ipin inv_vcm
x14 VDD D11 VSS vdacn b11 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_32
+ W_P= L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=32
x18 VDD D11 VSS vdacp b11 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_32
x1 VDD D10 VSS vdacn b10 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_16
+ W_P= L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=16
x2 VDD D9 VSS vdacn b9 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_8 W_P=
+ L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=8
x3 VDD D8 VSS vdacn b8 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_4 W_P=
+ L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=4
x4 VDD D7 VSS vdacn b7 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_2
+ W_P=1.0u L_P_SPDT=0.13u W_N=1.0u L_N_SPDT=0.13u Cu=cu n=2
x5 VDD D6 VSS vdacn b6 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_1 W_P=
+ L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=1
x6 VDD D5 VSS vdacp2 b5 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_16 W_P=
+ L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=16
x7 VDD D4 VSS vdacp2 b4 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_8 W_P=
+ L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=8
x8 VDD D3 VSS vdacp2 b3 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_4 W_P=
+ L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=4
x9 VDD D2 VSS vdacp2 b2 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_2 W_P=
+ L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=2
x11 VDD D1 VSS vdacp2 b1 vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n_1 W_P=
+ L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=1
x13 VDD D10 VSS vdacp b10 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_16
x15 VDD D9 VSS vdacp b9 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_8
x16 VDD D8 VSS vdacp b8 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_4
x19 VDD D7 VSS vdacp b7 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_2
x20 VDD D6 VSS vdacp b6 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_1
x21 VDD D5 VSS vdacn2 b5 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_16
x22 VDD D4 VSS vdacn2 b4 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_8
x23 VDD D3 VSS vdacn2 b3 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_4
x24 VDD D2 VSS vdacn2 b2 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_2
x25 VDD D1 VSS vdacn2 b1 vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_1
x27 VDD b_n_ctrl net3 VSS inverter_lv W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u N_C=1
x28 VDD net3 b_sample_n VSS inverter_lv W_P=10.0u L_P=0.13u W_N=10.0u L_N=0.13u N_C=1
x29 VDD b_ctrl net4 VSS inverter_lv W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u N_C=1
x31 VDD net4 b_sample VSS inverter_lv W_P=10.0u L_P=0.13u W_N=10.0u L_N=0.13u N_C=1
x32 VDD a_n_ctrl net5 VSS inverter_lv W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u N_C=1
x33 VDD net5 a_sample_n VSS inverter_lv W_P=20.0u L_P=0.13u W_N=10.0u L_N=0.13u N_C=1
x35 VDD a_ctrl net6 VSS inverter_lv W_P=1.0u L_P=0.13u W_N=1.0u L_N=0.13u N_C=1
x36 VDD net6 a_sample VSS inverter_lv W_P=20.0u L_P=0.13u W_N=10.0u L_N=0.13u N_C=1
x38 b_ctrl sample_pin net2 VDD VSS sg13g2_nor2_2
x39 a_n_ctrl net1 sample_pin VDD VSS sg13g2_nand2_2
x40 b_n_ctrl b_ctrl VDD VSS sg13g2_inv_2
x41 a_ctrl a_n_ctrl VDD VSS sg13g2_inv_2
x42 net2 a_sample_n net7 VDD VSS sg13g2_nand2_2
x43 net1 b_sample net8 VDD VSS sg13g2_nor2_2
x44 net7 a_sample VDD VSS sg13g2_inv_1
x45 net8 b_sample_n VDD VSS sg13g2_inv_1
XC1 vdacp vdacn2 cap_cmim w=3.23e-6 l=3e-6 m=2 mm_ok=1
XC2 vdacn vdacp2 cap_cmim w=3.23e-6 l=3e-6 m=2 mm_ok=1
x10 VDD VSS VSS vdacn2 VSS vcm vinn a_sample_n a_sample b_sample b_sample_n inv_vcm unit_cell_1
x17 VDD VSS VSS vdacp2 VSS vcm vinp a_sample a_sample_n b_sample b_sample_n inv_vcm unit_cell_n W_P=
+ L_P_SPDT=0.13u W_N= L_N_SPDT=0.13u Cu=cu n=1
XC3 vdacn2 VSS cap_cmim w=3e-6 l=3e-6 m=31 mm_ok=1
XC4 vdacp2 VSS cap_cmim w=3e-6 l=3e-6 m=31 mm_ok=1
* noconn b0
* noconn D0
**.ends
.end
