** sch_path: xschem/dac_icms_cell/unit_cell.sch
**.subckt unit_cell d v_top v_in v_cm bit b_sample_n b_sample inv_vcm a_sample a_sample_n VDD VSS
*.ipin d
*.iopin v_top
*.iopin v_in
*.iopin v_cm
*.ipin bit
*.ipin b_sample_n
*.ipin b_sample
*.ipin inv_vcm
*.ipin a_sample
*.ipin a_sample_n
*.iopin VDD
*.iopin VSS
XC1 v_c v_top cap_cmim w=3e-6 l=3e-6 m=@N mm_ok=1
XM3 v_c net7 VSS VSS sg13_lv_nmos w=1u l=0.13u ng=1 m=@N mm_ok=1
XM4 v_c net13 VDD VDD sg13_lv_pmos w=1u l=0.13u ng=1 m=@N mm_ok=1
x23 net12 net1 d VDD VSS sg13g2_nand2_1
x46 net6 bit d VDD VSS sg13g2_and2_1
x32 net1 bit VDD VSS sg13g2_inv_1
x10 net2 net14 inv_vcm VDD VSS sg13g2_and2_1
x11 net14 b_sample_n VDD VSS sg13g2_inv_1
x12 net9 net2 VDD VSS sg13g2_inv_1
XM5 v_c net4 v_cm VSS sg13_lv_nmos w=@W_N_SPDT l=@L_N_SPDT ng=1 m=@N mm_ok=1
XM6 v_c net10 v_cm VDD sg13_lv_pmos w=@W_P_SPDT l=@L_P_SPDT ng=1 m=@N mm_ok=1
XM7 v_in b_sample_n v_c VSS sg13_lv_nmos w=@W_N_SPDT l=@L_N_SPDT ng=1 m=@N mm_ok=1
XM8 v_in b_sample v_c VDD sg13_lv_pmos w=@W_P_SPDT l=@L_P_SPDT ng=1 m=@N mm_ok=1
XMdummy2 v_c b_sample_n v_c VDD sg13_lv_pmos w=@W_P_SPDT l=@L_P_SPDT ng=1 m=@N mm_ok=1
XMdummy1 v_c b_sample v_c VSS sg13_lv_nmos w=@W_N_SPDT l=@L_N_SPDT ng=1 m=@N mm_ok=1
XM9 net3 net2 VDD VDD sg13_lv_pmos w=3.0u l=0.13u ng=1 m=1 mm_ok=1
XM10 net3 net2 VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM11 net4 net3 VDD VDD sg13_lv_pmos w=3.0u l=0.13u ng=1 m=1 mm_ok=1
XM12 net4 net3 VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM13 net5 net6 VDD VDD sg13_lv_pmos w=3.0u l=0.13u ng=1 m=1 mm_ok=1
XM14 net5 net6 VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM15 net7 net5 VDD VDD sg13_lv_pmos w=3.0u l=0.13u ng=1 m=1 mm_ok=1
XM16 net7 net5 VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM17 net8 net9 VDD VDD sg13_lv_pmos w=3.0u l=0.13u ng=1 m=1 mm_ok=1
XM18 net8 net9 VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM19 net10 net8 VDD VDD sg13_lv_pmos w=3.0u l=0.13u ng=1 m=1 mm_ok=1
XM20 net10 net8 VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM21 net11 net12 VDD VDD sg13_lv_pmos w=3.0u l=0.13u ng=1 m=1 mm_ok=1
XM22 net11 net12 VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM23 net13 net11 VDD VDD sg13_lv_pmos w=3.0u l=0.13u ng=1 m=1 mm_ok=1
XM24 net13 net11 VSS VSS sg13_lv_nmos w=1.0u l=0.13u ng=1 m=1 mm_ok=1
XM1 v_top a_sample v_cm VSS sg13_lv_nmos w=@W_N_SPDT l=@L_N_SPDT ng=1 m=@N mm_ok=1
XM2 v_top a_sample_n v_cm VDD sg13_lv_pmos w=@W_P_SPDT l=@L_P_SPDT ng=1 m=@N mm_ok=1
XM25 v_in b_sample_n v_c VSS sg13_lv_nmos w=@W_N_SPDT l=@L_N_SPDT ng=1 m=@N mm_ok=1
XM26 v_in b_sample v_c VDD sg13_lv_pmos w=@W_P_SPDT l=@L_P_SPDT ng=1 m=@N mm_ok=1
**.ends

* expanding   symbol:  sg13g2_stdcells/sg13g2_nand2_1.sym # of pins=3
** sym_path: sg13g2_stdcells/sg13g2_nand2_1.sym
** sch_path: sg13g2_stdcells/sg13g2_nand2_1.sch
.subckt sg13g2_nand2_1 Y A B VDD VSS
*.iopin VDD
*.iopin VSS
*.ipin A
*.ipin B
*.opin Y
XM1 Y A net1 VSS sg13_lv_nmos w=740.00n l=130.00n ng=1 m=1 mm_ok=1
XM2 net1 B VSS VSS sg13_lv_nmos w=740.00n l=130.00n ng=1 m=1 mm_ok=1
XM3 Y A VDD VDD sg13_lv_pmos w=1.12u l=130.00n ng=1 m=1 mm_ok=1
XM4 Y B VDD VDD sg13_lv_pmos w=1.12u l=130.00n ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  sg13g2_stdcells/sg13g2_and2_1.sym # of pins=3
** sym_path: sg13g2_stdcells/sg13g2_and2_1.sym
** sch_path: sg13g2_stdcells/sg13g2_and2_1.sch
.subckt sg13g2_and2_1 X A B VDD VSS
*.ipin A
*.ipin B
*.opin X
*.iopin VDD
*.iopin VSS
XM1 net1 A net2 VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM2 net2 B VSS VSS sg13_lv_nmos w=640.00n l=130.00n ng=1 m=1 mm_ok=1
XM3 X net1 VSS VSS sg13_lv_nmos w=740.00n l=130.00n ng=1 m=1 mm_ok=1
XM4 net1 B VDD VDD sg13_lv_pmos w=840.00n l=130.00n ng=1 m=1 mm_ok=1
XM5 net1 A VDD VDD sg13_lv_pmos w=840.00n l=130.00n ng=1 m=1 mm_ok=1
XM6 X net1 VDD VDD sg13_lv_pmos w=1.12u l=130.00n ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  sg13g2_stdcells/sg13g2_inv_1.sym # of pins=2
** sym_path: sg13g2_stdcells/sg13g2_inv_1.sym
** sch_path: sg13g2_stdcells/sg13g2_inv_1.sch
.subckt sg13g2_inv_1 Y A VDD VSS
*.opin Y
*.ipin A
*.iopin VDD
*.iopin VSS
XM1 Y A VSS VSS sg13_lv_nmos w=740.00n l=130.00n ng=1 m=1 mm_ok=1
XM2 Y A VDD VDD sg13_lv_pmos w=1.12u l=130.00n ng=1 m=1 mm_ok=1
.ends

.end
