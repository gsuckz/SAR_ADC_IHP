v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {inverter/inverter_lv.sym} 0 -30 0 0 {name=x1 W_P=3.0u L_P=0.13u W_N=1.0u L_N=0.13u N_C=10}
