v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {logic/logic.sym} -500 590 2 1 {name=x3 }
C {lab_pin.sym} -330 -70 1 0 {name=p2 lab=b11}
C {lab_pin.sym} -360 90 0 0 {name=p4 lab=clk}
C {lab_pin.sym} -110 190 0 0 {name=p7 lab=VDD}
C {lab_pin.sym} -70 190 0 1 {name=p8 lab=VSS}
C {lab_pin.sym} -360 40 0 0 {name=p9 lab=rst}
C {lab_pin.sym} 180 0 0 1 {name=p10 lab=comp_in}
C {lab_pin.sym} -310 -70 1 0 {name=p12 lab=b10}
C {lab_pin.sym} -290 -70 1 0 {name=p13 lab=b9}
C {lab_pin.sym} -270 -70 1 0 {name=p14 lab=b8}
C {lab_pin.sym} -250 -70 1 0 {name=p15 lab=b7}
C {lab_pin.sym} -230 -70 1 0 {name=p16 lab=b6}
C {lab_pin.sym} -210 -70 1 0 {name=p17 lab=b5}
C {lab_pin.sym} -190 -70 1 0 {name=p18 lab=b4}
C {lab_pin.sym} -170 -70 1 0 {name=p19 lab=b3}
C {lab_pin.sym} -150 -70 1 0 {name=p20 lab=b2}
C {lab_pin.sym} -130 -70 1 0 {name=p21 lab=b1}
C {lab_pin.sym} -110 -70 1 0 {name=p22 lab=b0}
C {lab_pin.sym} -70 -70 1 0 {name=p30 lab=d11}
C {lab_pin.sym} -50 -70 1 0 {name=p31 lab=d10}
C {lab_pin.sym} -30 -70 1 0 {name=p32 lab=d9}
C {lab_pin.sym} -10 -70 1 0 {name=p33 lab=d8}
C {lab_pin.sym} 10 -70 1 0 {name=p34 lab=d7}
C {lab_pin.sym} 30 -70 1 0 {name=p35 lab=d6}
C {lab_pin.sym} 50 -70 1 0 {name=p36 lab=d5}
C {lab_pin.sym} 70 -70 1 0 {name=p37 lab=d4}
C {lab_pin.sym} 90 -70 1 0 {name=p38 lab=d3}
C {lab_pin.sym} 110 -70 1 0 {name=p39 lab=d2}
C {lab_pin.sym} 130 -70 1 0 {name=p40 lab=d1}
C {lab_pin.sym} 150 -70 1 0 {name=p41 lab=d0}
C {lab_pin.sym} -90 -70 1 0 {name=p1 lab=sample}
C {lab_pin.sym} 180 70 0 1 {name=p3 lab=eoc}
