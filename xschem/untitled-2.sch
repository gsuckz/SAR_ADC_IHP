v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
C {sg13g2_stdcells/IHP130_stdcells.sym} -100 -90 0 0 {name=x1}
